# Keil uVision project New_TD1.uvprojx, settings and files
target Target 1 (6070000::V6.7::.\ARMCLANG)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: New_TD1
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: test.asm
software components: CMSIS:CORE 5.0.1, Device:Startup 1.0.0
